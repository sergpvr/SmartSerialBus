# IAR project tuneauto.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: SD_FAT32
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: tuneauto.hex
  ILINK.IlinkOutputFile: tune.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: tuneauto.out
  group (top)
    ./: config.h hard.c hard.h main.c RegisterFn.c RegisterFn.h stm8s.h stm8s_type.h TuneTables.c TuneTables.h TuneWake.c TuneWake.h uart.c uart.h wake.c wake.h
